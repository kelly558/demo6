# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52832_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\..\..\drive;..\..\..\..\..\components;..\..\..\..\..\components\libraries\delay;..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\modules\nrfx;..\config;..\..\..\..\..\integration\nrfx;..\..\..\..\..\components\libraries\util;..\..\..\..\..\modules\nrfx\drivers;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\libraries\balloc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../../: main.c
  group drive
    ../../../../../drive/: led.c
software components: CMSIS:CORE 5.0.1, Device:Startup 8.32.1
